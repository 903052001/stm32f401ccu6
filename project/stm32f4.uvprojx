# Keil uVision project stm32f4.uvprojx, settings and files
target stm32f4 (6090000::V6.9::.\ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4 +hex
  AfterMake: fromelf --bin !L --output stm32f4_v100.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xC
  c include: ..\library\CMSIS\Device\ST\STM32F4xx\Include;..\library\CMSIS\Device\ST\STM32F4xx\Source\Templates\arm;..\library\CMSIS\Include;..\library\STM32F4xx_HAL_Driver\Inc;..\library\STM32F4xx_HAL_Driver\Inc\Legacy;..\project;..\library\STM32_USB_Device_Library\Core\Inc;..\library\STM32_USB_Device_Library\Class\CDC\Inc;..\library\FreeRTOS\portable\Keil\ARM_CM4F;..\library\FreeRTOS\portable\MemMang;..\library\FreeRTOS\include;..\unity\src;..\utility\common;..\utility\driver
  asm include: ..\Inc;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(command)
  group cmsis
    ./: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../library/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    ../library/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xc.s
  group hal_lib
    ../library/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_fmpsmbus.c stm32f4xx_hal_fmpsmbus_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_smbus.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fmpi2c.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group unity
    ../unity/src/: unity.c unity.h unity_internals.h
  group usb_core
    ../library/STM32_USB_Device_Library/Core/Src/: usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
    ../library/STM32_USB_Device_Library/Core/Inc/: usbd_conf.h usbd_core.h usbd_ctlreq.h usbd_desc.h usbd_ioreq.h usbd_def.h
  group usbd_cdc
    ../library/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c usbd_cdc_if.c
    ../library/STM32_USB_Device_Library/Class/CDC/Inc/: usbd_cdc.h usbd_cdc_if.h
  group FreeRTOS
    ../library/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../library/FreeRTOS/portable/Keil/ARM_CM4F/: port.c
    ../library/FreeRTOS/portable/MemMang/: heap_4.c
